# Repository Tomoshibi-technology/MovingDisplay3-Circuit

## KiCad design circuits/MD_module/Control/Control.kicad_pcb

Board: 4 copper layers, 35.0 x 35.0 mm, 102 parts (87 on the bottom side), 68 nets.

Parts:
C1, C2, C5, C6, C7, C8, C19, C20, C25: 0.1uF; C_0402_1005Metric
C3, C4: 22pF; C_0603_1608Metric
C9: 4.7uF; C_0603_1608Metric
C10, C14, C15, C26, C27: 10uF; C_1206_3216Metric
C11, C28: 22uF; C_0805_2012Metric
C12, C13: 1uF; C_0603_1608Metric
C16: 0.1uF; C_0603_1608Metric
C17, C18: 10uF; C_0805_2012Metric
C21, C22, C23: 330pF; C_0603_1608Metric
C24, C29: 1uF; C_0402_1005Metric
C30, C31: 1nF; C_0402_1005Metric
D1, D4, D6, D9, D10, D11: 1N5819WS; D_SOD-323_HandSoldering
D2, D3: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: SS2040FL; D_SOD-123
D7, D8: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x14_Pin; BoxHeader_2x07_P1.27mm_Horizontal
J2: Conn_02x13_Odd_Even; PinHeader_2x13_P1.27mm_Vertical
J3, J4: Conn_01x05_MountingPin; Molex_PicoBlade_53261-0571_1x05-1MP_P1.25mm_Horizontal
JP1, JP2: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 1uH; L_0603_1608Metric
Q1: SSM3J332R; SOT-23W
Q2: 2N7002; SOT-23
Q3: S8550; SOT-23
R1, R3, R6, R7, R8, R9, R10, R14, R16, R23, R31, R32, R33, R37: 10k; R_0402_1005Metric
R2, R4, R5: 1k; R_0402_1005Metric
R11, R15, R24: 20k; R_0402_1005Metric
R12: 5.1k; R_0402_1005Metric
R17: 1k; R_0603_1608Metric
R18: 75k; R_0603_1608Metric
R19: 10k; R_0603_1608Metric
R20, R21: 2k; R_0402_1005Metric
R22: 7.5k; R_0603_1608Metric
R25, R26, R27, R28: 2.2k; R_0402_1005Metric
R29, R30: 120; R_0402_1005Metric
R34, R35, R36: 100; R_0603_1608Metric
SW1: SW_SPST; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW3: SW_SPDT; SW_Slide_SPDT_SSAJ120100
SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: STM32G473CET6; LQFP-48_7x7mm_P0.5mm
U2: AZ1117CH-3.3; SOT-223-3_TabPin2
U3, U4: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U5: Encoder_Magnetic_AS5047P; TSSOP-14_4.4x5mm_P0.65mm
U6: DCDC_TPSM336x5
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C2.1, C5.1, C6.1, C7.1, C9.2, C13.1, C18.1, C19.1, C20.1, C24.2, C25.1, D1.2 (A), D6.2 (A), D9.1 (K), D10.1 (K), D11.1 (K), J2.16, Q3.2 (E), R16.2, R21.2, R25.1, R27.1, R32.2, R37.1, SW3.2 (B), SW4.5, SW4.6, SW4.7, SW4.8, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.2 (VO), U3.8 (VCC), U4.8 (VCC), U5.11 (VDD5V), U5.12 (VDD3V)
+5V: C12.1, C17.1, D6.1 (K), Q1.3 (D), R14.2, R20.2, U2.3 (VI)
/Power/PG: Q2.1 (G), R9.2, U6.1 (PGOOD)
/RS485/RS485_RA: J3.2, J4.2, JP1.1 (A), R25.2, U3.6 (A)
/RS485/RS485_RB: J3.3, J4.3, R26.1, R29.2, U3.7 (B)
/RS485/RS485_TA: J3.4, J4.4, JP2.1 (A), R27.2, U4.6 (A)
/RS485/RS485_TB: J3.5, J4.5, R28.1, R30.2, U4.7 (B)
BOOT0: R1.1, U1.45 (PB8-BOOT0)
CAL: J2.14, U1.27 (PB13)
CS1_Encoder: U1.16 (PB0), U5.1 (~CSn)
CS1_MD: J2.15, U1.17 (PB1)
Current_OUTA: C23.1, D9.2 (A), R34.2, U1.8 (PA0)
Current_OUTB: C22.1, D10.2 (A), R35.2, U1.9 (PA1)
Current_OUTC: C21.1, D11.2 (A), R36.2, U1.10 (PA2)
DIP_SW0: R6.2, SW4.1, U1.46 (PB9)
DIP_SW1: R7.2, SW4.2, U1.28 (PB14)
DIP_SW2: R31.2, SW4.3, U1.44 (PB7)
DIP_SW3: R33.2, SW4.4, U1.29 (PB15)
ENABLE: J2.4, U1.34 (PA12)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.1, D2.1 (K), D3.1 (K), D7.1 (K), D8.1 (K), J1.5, J1.7, J1.11, J2.18, J2.20, J2.22, J2.23, J2.24, J2.25, J2.26, J3.1, J3.MP (MountPin), J4.1, J4.MP (MountPin), Q2.2 (S), R1.2, R2.2, R3.2, R6.1, R7.1, R8.2, R12.1, R14.1, R15.2, R16.1, R19.2, R23.2, R24.2, R26.2, R28.2, R31.1, R33.1, R37.2, SW1.2 (B), SW1.3 (shell), SW3.4 (shell), SW3.5 (shell), U1.19 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.1 (GND), U3.5 (GND), U4.5 (GND), U5.5 (TEST), U5.13 (GND), U6.10 (GND), Y1.2, Y1.4
HSE_IN: C3.2, U1.5 (PF0), Y1.1
HSE_OUT: C4.2, U1.6 (PF1), Y1.3
INA_H: J2.17, U1.30 (PA8)
INA_L: J2.12, U1.2 (PC13)
INB_H: J2.19, U1.31 (PA9)
INB_L: J2.8, U1.4 (PC15)
INC_H: J2.21, U1.32 (PA10)
INC_L: J2.10, U1.3 (PC14)
LED0: R4.2, U1.43 (PB6)
LED1: R5.2, U1.33 (PA11)
MISO1: J2.9, R32.1, U1.14 (PA6), U5.3 (MISO)
MOSI1: J2.11, U1.15 (PA7), U5.4 (MOSI)
MainRX3_RS485TX: U1.25 (PB11), U3.1 (RO)
MainTX3_RS485RX: R22.2, U1.22 (PB10), U4.4 (DI)
NRST: C8.1, J1.12, SW1.1 (A), U1.7 (NRST)
unnamed: C16.1, R17.2, R18.1
unnamed: D1.1 (K), J1.3, R2.1
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R5.1
unnamed: C11.1, C28.1, D4.2 (A), Q1.2 (S), R10.1, R11.2, U6.4 (VOUT)
unnamed: D5.1 (K), L1.1
unnamed: D7.2 (A), R20.1
unnamed: D8.2 (A), R21.1
unnamed: JP1.2 (B), R29.1
unnamed: JP2.2 (B), R30.1
unnamed: Q1.1 (G), Q2.3 (D), R10.2
unnamed: Q3.1 (B), R22.1
unnamed: Q3.3 (C), R24.1, U4.2 (~RE), U4.3 (DE)
unnamed: R3.1, U1.18 (PB2)
unnamed: R23.1, U3.2 (~RE), U3.3 (DE)
unnamed: TP3.1, U5.7 (A)
unnamed: TP2.1, U5.6 (B)
unnamed: R11.1, R12.2, U6.9 (FB)
unnamed: C29.1, R9.1, U6.8 (VCC), U6.11 (RT)
Phase_A: TP4.1, U1.41 (PB4)
Phase_B: TP1.1, U1.42 (PB5)
SCLK1: J2.13, U1.13 (PA5), U5.2 (CLK)
SOA: J2.7, R34.1
SOB: J2.5, R35.1
SOC: J2.3, R36.1
SWCLK: J1.6, U1.38 (PA14)
SWDIO: J1.4, U1.37 (PA13)
SWO: J1.8, U1.40 (PB3)
Slide_SW0: R8.1, SW3.1 (A), U1.26 (PB12)
VCC: C10.1, C15.1, C26.1, C27.1, C31.2, D4.1 (K), L1.2, R15.1, U6.2 (EN), U6.3 (VIN)
VDD: C14.1, C30.2, D5.2 (A), J2.1, J2.2, R17.1
V_Meas.: R18.2, R19.1, U1.11 (PA3)
nFAULT: J2.6, U1.12 (PA4)

## KiCad design circuits/MD_module/MD/MD.kicad_pcb

Parts:
C1: 0.1uF; C_0402_1005Metric
J4: Conn_02x13_Odd_Even; PinSocket_2x13_P1.27mm_Vertical
R3: 10k; R_0402_1005Metric

Connections:
+3.3V: C1.1, J4.16, R3.1; also elsewhere on the board
CAL: J4.14; also elsewhere on the board
CS1_MD: J4.15; also elsewhere on the board
ENABLE: J4.4; also elsewhere on the board
GND: C1.2, J4.18, J4.20, J4.22, J4.23, J4.24, J4.25, J4.26, R3.2; also elsewhere on the board
INA_H: J4.17; also elsewhere on the board
INA_L: J4.12; also elsewhere on the board
INB_H: J4.19; also elsewhere on the board
INB_L: J4.8; also elsewhere on the board
INC_H: J4.21; also elsewhere on the board
INC_L: J4.10; also elsewhere on the board
MISO1: J4.9; also elsewhere on the board
MOSI1: J4.11; also elsewhere on the board
SCLK1: J4.13; also elsewhere on the board
SOA: J4.7; also elsewhere on the board
SOB: J4.5; also elsewhere on the board
SOC: J4.3; also elsewhere on the board
VDD: J4.1, J4.2; also elsewhere on the board
nFAULT: J4.6; also elsewhere on the board

Parts:
C2, C17: 100uF; Capacitor_Alum_Radial_5.0x11.0mm_Horizontal
C3: 1uF; C_0603_1608Metric
C4: 10uF; C_1206_3216Metric
C14: 1uF; C_0402_1005Metric
D5: 1N5819WS; D_SOD-323_HandSoldering
J5: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
Q1: 2N7002; SOT-23
Q2, Q6: DI035P04PT; Package_TSON-Advance
R4: 100k; R_0402_1005Metric
R18: 47k; R_0402_1005Metric
R19, R24, R26, R28, R29: 10k; R_0402_1005Metric
R30: 20k; R_0402_1005Metric
SW4: SW_SPDT; SW_Slide_DPDT_SSSS820101

Connections:
/Power/24VBAT: J5.2, Q2.5 (D)
/Power/PowerSW: Q1.1 (G), R4.1, SW4.1 (A)
/Power/S-S: C14.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R18.1, R26.1, R28.1
GND: C2.2, C3.2, C4.2, C17.2, D5.2 (A), J5.1, Q1.2 (S), R4.2, R19.2, R24.2, R30.2, SW4.4 (shell), SW4.5 (shell), SW4.6 (shell), SW4.G1 (shell), SW4.G2 (shell), SW4.G3 (shell), SW4.G4 (shell); also elsewhere on the board
unnamed: Q1.3 (D), R29.2
unnamed: Q2.4 (G), R24.1, R26.2
unnamed: C14.2, Q6.4 (G), R28.2, R29.1
unnamed: R18.2, R19.1, SW4.2 (B)
VDD: C2.1, C3.1, C4.1, C17.1, D5.1 (K), Q6.5 (D), R30.1; also elsewhere on the board

Notes on the sheet:
主電源スイッチ
電源電圧測定
インジケーターLED
保護回路・スイッチ
Conn to Power
PowerModule
Capacitor
TestPoint

Parts:
C23, C24: 10uF; C_1206_3216Metric
C25, C29: 0.1uF; C_0402_1005Metric
C26, C27: 1uF; C_0402_1005Metric
C28: 47nF; C_0603_1608Metric
C33, C34, C37, C38, C40, C41: CR_snub; C_0603_1608Metric
C35, C36, C39: C_snub; C_0603_1608Metric
D1: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D14, D15, D16, D17, D18, D19: SS2040FL; D_SOD-123
D20, D21, D22: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J6: Conn_01x03_Pin; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
Q7, Q8, Q9, Q10, Q11, Q12: TPN19008QM; Package_TSON-Advance
R1: 1k; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R56, R61, R66: 7m; R_2512_6332Metric
R67, R68, R70, R71, R73, R74: CR_snub; R_0603_1608Metric
R69, R72, R75: 20k; R_0402_1005Metric
U6: Driver_FETGate_DRV8323S

Connections:
+3.3V: C29.1, R1.2, R2.2, U6.24 (VREF); also elsewhere on the board
/MotorDriver/BridgeA_S: C34.1, C35.1, D15.2 (A), Q7.1 (S), Q7.2 (S), Q7.3 (S), R56.2, U6.9 (SPA)
/MotorDriver/BridgeB_S: C36.1, C38.1, D17.2 (A), Q8.1 (S), Q8.2 (S), Q8.3 (S), R61.2, U6.12 (SPB)
/MotorDriver/BridgeC_S: C39.1, C41.1, D19.2 (A), Q12.1 (S), Q12.2 (S), Q12.3 (S), R66.2, U6.19 (SPC)
/MotorDriver/Phase_U: C33.1, D14.2 (A), D15.1 (K), J6.3, Q7.5 (D), Q10.1 (S), Q10.2 (S), Q10.3 (S), R68.2, R69.1, U6.7 (SHA)
/MotorDriver/Phase_V: C37.1, D16.2 (A), D17.1 (K), J6.2, Q8.5 (D), Q9.1 (S), Q9.2 (S), Q9.3 (S), R71.2, R72.1, U6.14 (SHB)
/MotorDriver/Phase_W: C40.1, D18.2 (A), D19.1 (K), J6.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), R74.2, R75.1, U6.17 (SHC)
CAL: U6.31 (CAL); also elsewhere on the board
CS1_MD: U6.29 (GAIN_SCS_N); also elsewhere on the board
ENABLE: U6.30 (ENABLE); also elsewhere on the board
GND: C23.2, C24.2, C25.2, C26.2, C29.2, D20.1 (K), D21.1 (K), D22.1 (K), R56.1, R61.1, R66.1, U6.10 (SNA), U6.11 (SNB), U6.20 (SNC), U6.32 (AGND), U6.40 (PGND), U6.41 (PAD); also elsewhere on the board
INA_H: U6.34 (INHA); also elsewhere on the board
INA_L: U6.35 (INLA); also elsewhere on the board
INB_H: U6.36 (INHB); also elsewhere on the board
INB_L: U6.37 (INLB); also elsewhere on the board
INC_H: U6.38 (INHC); also elsewhere on the board
INC_L: U6.39 (INLC); also elsewhere on the board
MISO1: U6.26 (MODE_SDO); also elsewhere on the board
MOSI1: U6.27 (IDRIVE_SDI); also elsewhere on the board
unnamed: C33.2, R67.1
unnamed: C34.2, R68.1
unnamed: C37.2, R70.1
unnamed: C38.2, R71.1
unnamed: C40.2, R73.1
unnamed: C41.2, R74.1
unnamed: D1.2 (A), R1.1
unnamed: D20.2 (A), R69.2
unnamed: D21.2 (A), R72.2
unnamed: D22.2 (A), R75.2
unnamed: Q7.4 (G), U6.8 (GLA)
unnamed: Q8.4 (G), U6.13 (GLB)
unnamed: Q9.4 (G), U6.15 (GHB)
unnamed: Q10.4 (G), U6.6 (GHA)
unnamed: Q11.4 (G), U6.16 (GHC)
unnamed: Q12.4 (G), U6.18 (GLC)
unnamed: C28.1, U6.2 (CPH)
unnamed: C28.2, U6.1 (CPL)
unnamed: C26.1, U6.33 (DVDD)
unnamed: C27.2, U6.3 (VCP)
SCLK1: U6.28 (VDS_SCLK); also elsewhere on the board
SOA: U6.23 (SOA); also elsewhere on the board
SOB: U6.22 (SOB); also elsewhere on the board
SOC: U6.21 (SOC); also elsewhere on the board
VDD: C23.1, C24.1, C25.1, C27.1, C35.2, C36.2, C39.2, D14.1 (K), D16.1 (K), D18.1 (K), Q9.5 (D), Q10.5 (D), Q11.5 (D), R67.2, R70.2, R73.2, U6.4 (VM), U6.5 (VDRAIN); also elsewhere on the board
nFAULT: D1.1 (K), R2.1, U6.25 (FAULT_N); also elsewhere on the board

Notes on the sheet:
CR Snubber + LED
プルアップなど
DRV8323S
MotorDriver
Conn to Motor
Low Pass Filter
C Snubber

Board: 4 copper layers, 35.0 x 35.0 mm, 70 parts (34 on the bottom side), 52 nets.

## KiCad design circuits/DCDC/DCDC.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; C_0402_1005Metric
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: Conn_01x08_MountingPin; Molex_PicoBlade_53261-0871_1x08-1MP_P1.25mm_Horizontal
JP1, JP2, JP3, JP4, JP5, JP6: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R3, R4, R5, R6, R9, R10, R11, R12, R15, R16, R17, R18: 2.2k; R_0402_1005Metric
U1, U2, U3, U4, U5, U6: MAX485E; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, R3.1, R5.1, R9.1, R11.1, R15.1, R17.1, U1.8 (VCC), U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U6.8 (VCC); also elsewhere on the board
/Panel_PWRCtrl: J1.8; also elsewhere on the board
/RS485/RS485_Panel0: J1.2, U1.6 (A)
/RS485/RS485_Panel1: J1.3, U2.6 (A)
/RS485/RS485_Panel2: J1.4, U3.6 (A)
/RS485/RS485_Panel3: J1.5, U4.6 (A)
/RS485/RS485_Panel4: J1.6, U5.6 (A)
/RS485/RS485_Panel5: J1.7, U6.6 (A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.1, J1.MP (MountPin), R4.2, R6.2, R10.2, R12.2, R16.2, R18.2, U1.2 (~RE), U1.3 (DE), U1.4 (DI), U1.5 (GND), U2.2 (~RE), U2.3 (DE), U2.4 (DI), U2.5 (GND), U3.2 (~RE), U3.3 (DE), U3.4 (DI), U3.5 (GND), U4.2 (~RE), U4.3 (DE), U4.4 (DI), U4.5 (GND), U5.2 (~RE), U5.3 (DE), U5.4 (DI), U5.5 (GND), U6.2 (~RE), U6.3 (DE), U6.4 (DI), U6.5 (GND); also elsewhere on the board
unnamed: H1.1, JP1.1 (A)
unnamed: JP1.2 (B), U1.1 (RO)
unnamed: H2.1, JP2.1 (A)
unnamed: JP2.2 (B), U2.1 (RO)
unnamed: H3.1, JP3.1 (A)
unnamed: JP3.2 (B), U3.1 (RO)
unnamed: H4.1, JP4.1 (A)
unnamed: JP4.2 (B), U4.1 (RO)
unnamed: H5.1, JP5.1 (A)
unnamed: JP5.2 (B), U5.1 (RO)
unnamed: H6.1, JP6.1 (A)
unnamed: JP6.2 (B), U6.1 (RO)
unnamed: R3.2, R4.1, U1.7 (B)
unnamed: R5.2, R6.1, U2.7 (B)
unnamed: R9.2, R10.1, U3.7 (B)
unnamed: R11.2, R12.1, U4.7 (B)
unnamed: R15.2, R16.1, U5.7 (B)
unnamed: R17.2, R18.1, U6.7 (B)

Notes on the sheet:
Panel4
Panel1
Panel5
Panel3
Panel0
Panel2
Conn to Panel
Trans to RS485
