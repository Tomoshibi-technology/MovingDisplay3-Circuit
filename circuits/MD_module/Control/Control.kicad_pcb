# Repository Tomoshibi-technology/MovingDisplay3-Circuit (continued)

## KiCad design circuits/DCDC/DCDC.kicad_pcb (continued)

Parts:
C7, C11, C29: 1uF_50V; C_0603_1608Metric
C8, C10, C21: 1uF; C_0402_1005Metric
C9: 0.1uF_50V; C_0402_1005Metric
C12, C13, C14, C15: 10uF_50V; C_0805_2012Metric
C16, C19, C22, C25, C27: 1nF; C_0603_1608Metric
C17: 1500pF; C_0603_1608Metric
C18: 47pF; C_0603_1608Metric
C20: 2700pF; C_0603_1608Metric
C23: C_snub; C_0603_1608Metric
C24, C28, C30, C34: 0.1uF; C_0402_1005Metric
C26: 330uF; CP_EIA-7343-20_Kemet-V
C31, C32: 100uF; Capacitor_Alum_Radial_5.0x11.0mm_Horizontal
C33: 4700pF; C_0603_1608Metric
D1, D2, D3, D6, D7: 1N5819WS; Diode_SOD-323
D4, D5: SS2040FL; D_SOD-123
D8: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: FerriteBead; L_0603_1608Metric
H7: MountingHole_Pad; TestPoint_Pad_D1.5mm
H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23: MountingHole_Pad; MountingHole_3.7mm_Pad_Via
J2: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
L1: 2.2uH; Inductor_ETQ-P4M_KVK
Q1, Q3: SSM6J808R; Package_TSOP6F
Q2, Q11: 2N7002; SC-59
Q4, Q5, Q6: SS8550; SC-59
Q7: SS8050; SC-59
Q8, Q9: TPH11006NL; Package_SOP-Advance
Q10: MTP4835I3; TO-252-2
R1, R2: Rg; R_0603_1608Metric
R19, R21, R22, R23, R24, R25, R26, R28, R42, R49, R50, R53: 10k; R_0402_1005Metric
R20, R27, R41: 20k; R_0402_1005Metric
R29, R32: 510; R_0402_1005Metric
R30, R36, R48, R51: 1k; R_0402_1005Metric
R31: 10M; R_0603_1608Metric
R34: 12k; R_0603_1608Metric
R35: 2.7k; R_0603_1608Metric
R38: R_snub; R_0603_1608Metric
R39: 5.1k; R_0402_1005Metric
R40: 3.3k; R_0402_1005Metric
R43, R44: 16k; R_0603_1608Metric
R45: 620; R_0603_1608Metric
R46: 7.5k; R_0603_1608Metric
R47: 2k; R_0603_1608Metric
SW1: SW_SPDT_White; SW_Slide_SPDT_IS-1235-G
TP1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U7: NJM78L12S_SOT89; SOT-89-3
U8: UC3843_SOIC8; SOIC-8_3.9x4.9mm_P1.27mm
U9: Driver_FETGate_RT9624A; SOP-8_3.9x4.9mm_P1.27mm
U10: NJU77701; SOT-23-5
U11: M51957B; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C30.2, D7.2 (A), H8.1, H10.1, H12.1, H14.1, H16.1, H18.1, H20.1, H22.1, Q10.2 (D), R50.1, R51.2, U10.5 (V+); also elsewhere on the board
+12V: C10.1, C24.1, C28.2, C34.2, D2.2 (A), R26.2, R41.2, U7.1 (OUT), U8.7 (VCC), U9.4 (VCC), U11.7 (VCC)
+BATT: J2.2, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
/Panel_PWRCtrl: Q11.1 (G), R53.1; also elsewhere on the board
/Power/CLK: C17.1, Q6.3 (C), Q7.1 (B), U8.4 (RC), U10.3 (+)
/Power/FB: C18.1, C20.2, R31.2, R43.1, R44.2, R45.1, U8.2 (FB)
/Power/HG: Q8.4 (G), R1.1
/Power/LG: Q9.4 (G), R2.1
/Power/PowerSW: Q2.1 (G), R22.2, R25.1
/Power/S-S: C8.1, Q1.4 (S), Q3.4 (S), R21.1, R23.1, SW1.2 (B)
/Power/SHDN: Q10.1 (G), Q11.3 (D), R49.2
/Power/SW: C29.2, D4.2 (A), D5.1 (K), L1.1, Q8.1 (S), Q8.2 (S), Q8.3 (S), Q9.5 (D), R38.2, U9.7 (PHS)
/Power/Slope: R35.1, R36.2, U8.3 (CS)
/Power/V_Surv: R46.1, R47.1, U11.2 (IN)
GND: C7.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C19.2, C21.2, C22.2, C23.1, C24.2, C25.2, C26.2, C28.1, C30.1, C31.2, C32.2, C33.1, C34.1, D3.2 (A), D5.2 (A), D8.1 (K), H9.1, H11.1, H13.1, H15.1, H17.1, H19.1, H21.1, H23.1, J2.1, Q2.2 (S), Q4.3 (C), Q9.1 (S), Q9.2 (S), Q9.3 (S), R19.2, R20.2, R25.2, R26.1, R27.2, R30.1, R36.1, R40.1, R42.1, R44.1, R47.2, R48.2, R50.2, R53.2, TP1.1, U7.2 (GND), U8.5 (GND), U9.6 (GND), U10.2 (V-), U11.4 (GND); also elsewhere on the board
unnamed: C20.1, R34.1
unnamed: C23.2, R38.1
unnamed: C27.1, R45.2
unnamed: C22.1, D1.1 (K), FB1.1
unnamed: C25.1, C26.1, C27.2, D6.2 (A), D7.1 (K), L1.2, Q10.3 (S), R43.2, R46.2, R48.1, R49.1
unnamed: D8.2 (A), R51.1
unnamed: Q1.3 (G), R19.1, R21.2
unnamed: Q2.3 (D), R24.2
unnamed: C8.2, Q3.3 (G), R23.2, R24.1
unnamed: C11.1, Q4.1 (B), R28.1
unnamed: C18.2, Q4.2 (E), R31.1, R34.2, U8.1 (COMP)
unnamed: Q5.1 (B), Q5.3 (C), Q6.1 (B), R30.2
unnamed: Q5.2 (E), R29.1
unnamed: Q6.2 (E), R32.1
unnamed: C21.1, Q7.3 (C), R28.2, R29.2, R32.2, U8.8 (VREF)
unnamed: Q7.2 (E), R35.2
unnamed: Q11.2 (S), U11.6 (OUT)
unnamed: R22.1, SW1.1 (A)
unnamed: R39.2, U8.6 (OUT)
unnamed: C29.1, U9.1 (BT)
unnamed: R41.1, R42.2, U9.3 (EN)
unnamed: R2.2, U9.5 (LG)
unnamed: R39.1, R40.2, U9.2 (PWM)
unnamed: R1.2, U9.8 (UG)
unnamed: H7.1, U10.1, U10.4 (-)
unnamed: C33.2, U11.5 (Cdelay)
VCC: C7.1, C9.2, C19.1, C32.1, D2.1 (K), FB1.2, R20.1, U7.3 (IN)
VDD: C12.1, C13.1, C14.1, C15.1, C16.1, C31.1, D1.2 (A), D3.1 (K), D4.1 (K), D6.1 (K), Q3.1 (D), Q3.2 (D), Q3.5 (D), Q3.6 (D), Q8.5 (D), R27.1

Notes on the sheet:
Capacitor
TestPoint
補機電源生成
保護回路・スイッチ
パワー段
PowerModule
5V surveillance
主電源スイッチ
インジケーターLED
Clock Buffer
Conn to Power
制御段
Panelとの接続

Board: 2 copper layers, 100.0 x 100.0 mm, 145 parts (145 on the bottom side), 67 nets.

## KiCad design circuits/Imposition/1stLayer_Power/1stLayer_Power.kicad_pcb

Board: 2 copper layers, 62.9 x 90.7 mm, 53 parts (4 on the bottom side), 37 nets.

Parts:
C1, C4: 330uF; C_Elec_8x10.2
C3: 1uF; C_0603_1608Metric
D2: 1N5819WS; D_SOD-323_HandSoldering
D3: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F2: Fuse; Fuseholder_Blade_Mini_Keystone_3568
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
H3, H11, H19, H21: MountingHole_Pad; Pad_THTPad_1.0x1.0mm_Drill0.65mm
H4, H5, H6, H7, H8, H9, H10, H12, H13, H14, H15, H16, H17, H18, H20, H22: MountingHole_Pad; Pad_THTPad_D1.0mm_Drill0.65mm
J1, J2, J3: Conn_01x14_Pin; BoxHeader_2x07_P1.27mm_Horizontal
J4: Conn_01x02_Male; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J5, J6, J8, J9: Conn_01x02_Male; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
J7, J10: Conn_01x08_MountingPin; Molex_PicoBlade_53398-0871_1x08-1MP_P1.25mm_Vertical
J11: Conn_01x10_Socket; PinSocket_1x10_P1.27mm_Vertical
Q1: 2N7002; SOT-23
Q4, Q6: SQS141ELNW; Package_TSON-Advance
R3: 100k; R_0603_1608Metric
R5, R6, R7, R8, R9, R10: 10k; R_0603_1608Metric
R11: 20k; R_0603_1608Metric
SW1: SW_SPDT; SW_Slide_DPDT_SS22F06G5-G
TP1, TP2: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm

Connections:
+BATT: F2.1, J4.2
/1stLayer/3.3V_Drive: J1.3, J2.3
/1stLayer/3.3V_Wireless: J3.3, J11.2
/Conn1/Panel_PWRCtrl: H10.1, J7.8
/Conn1/RS485_Panel0: H4.1, J7.2
/Conn1/RS485_Panel1: H5.1, J7.3
/Conn1/RS485_Panel2: H6.1, J7.4
/Conn1/RS485_Panel3: H7.1, J7.5
/Conn1/RS485_Panel4: H8.1, J7.6
/Conn1/RS485_Panel5: H9.1, J7.7
/Conn3/Panel_PWRCtrl: H18.1, J10.8
/Conn3/RS485_Panel0: H12.1, J10.2
/Conn3/RS485_Panel1: H13.1, J10.3
/Conn3/RS485_Panel2: H14.1, J10.4
/Conn3/RS485_Panel3: H15.1, J10.5
/Conn3/RS485_Panel4: H16.1, J10.6
/Conn3/RS485_Panel5: H17.1, J10.7
/Power/PowerSW: Q1.1 (G), R3.1, SW1.1 (A)
/Power/S-S: C3.1, Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R5.1, R8.1, R9.1
GND: C1.2, C4.2, D2.2 (A), D3.1 (K), H1.1, H3.1, H11.1, H19.1, H21.1, J1.5, J1.7, J1.11, J2.5, J2.7, J2.11, J3.5, J3.7, J3.11, J4.1, J5.1, J6.1, J7.1, J7.MP (MountPin), J8.1, J9.1, J10.1, J10.MP (MountPin), J11.1, J11.3, J11.5, J11.7, J11.9, Q1.2 (S), R3.2, R6.2, R7.2, SW1.4 (C), SW1.5 (A), SW1.6 (A), SW1.SH (A), TP2.1
NRST_Drive: J1.12, J2.12
NRST_Wireless: J3.12, J11.10
unnamed: D3.2 (A), R11.1
unnamed: H20.1, J8.2
unnamed: H22.1, J9.2
unnamed: Q1.3 (D), R10.2
unnamed: F2.2, Q4.5 (D)
unnamed: Q4.4 (G), R7.1, R8.2
unnamed: C3.2, Q6.4 (G), R9.2, R10.1
unnamed: R5.2, R6.1, SW1.2 (B)
SWCLK_Drive: J1.6, J2.6
SWCLK_Wireless: J3.6, J11.6
SWDIO_Drive: J1.4, J2.4
SWDIO_Wireless: J3.4, J11.4
SWO_Drive: J1.8, J2.8
SWO_Wireless: J3.8, J11.8
VDD: C1.1, C4.1, D2.1 (K), H2.1, J5.2, J6.2, Q6.5 (D), R11.2, TP1.1

## KiCad design circuits/Drive/Drive.kicad_pcb

Board: 2 copper layers, 102.2 x 125.7 mm, 184 parts (154 on the bottom side), 99 nets.

Parts:
C1, C2, C3, C4, C7, C8, C9, C10, C27, C28, C29, C30, C31, C35, C36: 0.1uF; C_0402_1005Metric
C5, C6: 22pF; C_0603_1608Metric
C11, C13, C19, C20, C21, C34: 1uF; C_0402_1005Metric
C12: 4.7uF; C_0603_1608Metric
C14, C15: 2.2uF; C_0402_1005Metric
C16: 10uF; C_1206_3216Metric
C17: ADJ_ST; C_0603_1608Metric
C18, C25, C26, C41: 22uF; C_0805_2012Metric
C22, C23, C37, C38: 47uF; CP_Elec_6.3x5.4
C24: 0.1uF; C_0603_1608Metric
C32, C33: 100uF; Capacitor_Alum_Radial_5.0x11.0mm_Horizontal
C40: 10uF; C_0805_2012Metric
D1, D2, D4, D6: 1N5819WS; D_SOD-323_HandSoldering
D3: D_Zener; D_SOD-323_HandSoldering
D5: SS2040FL; D_SOD-123
D7, D8, D9: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10, D11: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: LightGreen; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D14: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
H3, H4: MountingHole_Pad; TestPoint_Pad_1.5x1.5mm
J1: Conn_01x14_Pin; BoxHeader_2x07_P1.27mm_Horizontal
J2, J3, J4, J5, J6: Conn_01x02_Pin; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
J7: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
J8, J9: Conn_01x05_MountingPin; Molex_PicoBlade_53261-0571_1x05-1MP_P1.25mm_Horizontal
J10, J11: Conn_01x06_MountingPin; Molex_PicoBlade_53398-0671_1x06-1MP_P1.25mm_Vertical
JP4, JP5: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 1uH; L_0603_1608Metric
Q1, Q3, Q6, Q11: SSM3J332R; SOT-23W
Q2, Q4, Q10, Q12, Q13, Q14, Q17: S8550; SOT-23
Q5, Q8, Q15, Q16, Q18: 2N7002; SOT-23
Q7, Q9: SSM6J808R; Package_TSOP6F
R1, R3, R6, R8, R9, R10, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R36, R45, R54, R55, R56, R57, R58, R59, R68, R69, R73: 10k; R_0402_1005Metric
R4, R7, R31, R32, R33, R52, R53, R62, R63, R66, R67: 1k; R_0402_1005Metric
R11, R35, R44, R72: 20k; R_0402_1005Metric
R12, R64, R65: 5.1k; R_0402_1005Metric
R28: 1k; R_0603_1608Metric
R29: 75k; R_0603_1608Metric
R30: 10k; R_0603_1608Metric
R34, R43, R71: 7.5k; R_0603_1608Metric
R37, R38, R39, R40, R46, R47, R48, R49, R74, R75, R76, R77: 2.2k; R_0402_1005Metric
R41, R42, R50, R51, R78, R79: 120; R_0402_1005Metric
R60, R61: PullUP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW2: SW_SPDT_White; SW_Slide_SPDT_IS-1235-G
SW3: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW4: SW_SPDT; SW_Slide_SPDT_SSSS213202
SW5: SW_SPST; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
TP3: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: AZ1117CH-3.3; SOT-223-3_TabPin2
U2: DCDC_TPSM336x5
U3, U4, U5, U6, U11, U12: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U7: BNO055; Sensor_Motion_Aktk_BNO055
U8: STM32H723VGTx; LQFP-100_14x14mm_P0.5mm
U10: Sensor_OpticalFlowSensor_PIM573; Sensor_OpticalFlowSensor_PIM453
Y2: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C12.1, C13.1, C21.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C34.2, C35.1, C36.1, D1.2 (A), D6.2 (A), Q13.2 (E), Q14.2 (E), Q17.2 (E), R27.2, R33.2, R37.1, R39.1, R46.1, R48.1, R60.1, R61.1, R66.1, R74.1, R76.1, SW3.5, SW3.6, SW3.7, SW3.8, SW4.2 (B), SW5.2 (B), U1.2 (VO), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U6.8 (VCC), U7.3 (VDD), U8.6 (VBAT), U8.11 (VDD), U8.20 (VREF+), U8.21 (VDDA), U8.27 (VDD), U8.50 (VDD), U8.75 (VDD), U8.100 (VDD), U10.1 (3-5V), U11.8 (VCC), U12.8 (VCC)
+5V: C20.1, C25.1, D3.1 (K), D6.1 (K), Q3.2 (S), Q4.2 (E), Q11.2 (S), Q12.2 (E), R15.2, R32.2, U1.3 (VI)
+BATT: C32.1, C33.1, C37.1, H1.1, J2.2, J3.2, J4.2, J5.2, J6.2, J10.2, J11.2, Q7.1 (D), Q7.2 (D), Q7.5 (D), Q7.6 (D)
/Power/IND: Q1.3 (D), Q2.2 (E), Q3.3 (D), R8.2, R31.2
/Power/PG: Q5.1 (G), R10.2, U2.1 (PGOOD)
/Power/PowerSW: Q8.1 (G), R20.2, R22.1
/Power/S-S: C19.1, Q7.4 (S), Q9.4 (S), R18.1, R19.1, SW2.2 (B)
/Power/VSYS: Q6.3 (D), Q10.2 (E), Q11.3 (D), R17.2
/Power/Vout: C18.1, C41.1, D2.2 (A), Q6.2 (S), R6.1, R7.1, R11.2, R14.1, U2.4 (VOUT)
/RS485_MD/RS485MD_RA: J8.4, J9.4, JP5.1 (A), R48.2, U6.6 (A)
/RS485_MD/RS485MD_RB: J8.5, J9.5, R49.1, R51.2, U6.7 (B)
/RS485_MD/RS485MD_TA: J8.2, J9.2, JP4.1 (A), R46.2, U5.6 (A)
/RS485_MD/RS485MD_TB: J8.3, J9.3, R47.1, R50.2, U5.7 (B)
/RS485_RingNW/RS485RingX_RA: J10.5, R39.2, R42.1, U4.6 (A)
/RS485_RingNW/RS485RingX_RB: J10.6, R40.1, R42.2, U4.7 (B)
/RS485_RingNW/RS485RingX_TA: J10.3, R37.2, R41.1, U3.6 (A)
/RS485_RingNW/RS485RingX_TB: J10.4, R38.1, R41.2, U3.7 (B)
/RS485_RingNW/RS485RingY_RA: J11.5, R76.2, R79.1, U12.6 (A)
/RS485_RingNW/RS485RingY_RB: J11.6, R77.1, R79.2, U12.7 (B)
/RS485_RingNW/RS485RingY_TA: J11.3, R74.2, R78.1, U11.6 (A)
/RS485_RingNW/RS485RingY_TB: J11.4, R75.1, R78.2, U11.7 (B)
BOOT0: R1.1, U8.94 (BOOT0)
CS2_Mouse: U8.51 (PB12), U10.2 (CS)
DIPSW0: R54.2, SW3.1, U8.64 (PC7)
DIPSW1: R55.2, SW3.2, U8.65 (PC8)
DIPSW2: R57.2, SW3.3, U8.66 (PC9)
DIPSW3: R58.2, SW3.4, U8.67 (PA8)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.1, C35.2, C36.2, C37.2, C38.2, C40.1, C41.2, D3.2 (A), D4.2 (A), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), H2.1, J1.5, J1.7, J1.11, J2.1, J3.1, J4.1, J5.1, J6.1, J7.A12 (GND), J7.B12 (GND), J7.S1 (SHIELD), J8.1, J8.MP (MountPin), J9.1, J9.MP (MountPin), J10.1, J10.MP (MountPin), J11.1, J11.MP (MountPin), Q5.2 (S), Q8.2 (S), Q15.2 (S), Q16.2 (S), Q18.2 (S), R1.2, R3.2, R4.1, R7.2, R8.1, R9.1, R12.1, R13.1, R15.1, R16.2, R17.1, R22.2, R23.1, R24.2, R25.1, R26.2, R27.1, R30.2, R35.2, R36.2, R38.2, R40.2, R44.2, R45.2, R47.2, R49.2, R54.1, R55.1, R56.2, R57.1, R58.1, R59.2, R62.2, R64.1, R65.1, R68.2, R69.2, R72.2, R73.2, R75.2, R77.2, SW1.2 (B), TP3.1, U1.1 (GND), U2.10 (GND), U3.5 (GND), U4.5 (GND), U5.5 (GND), U6.5 (GND), U7.2 (GND), U8.10 (VSS), U8.19 (VSSA), U8.26 (VSS), U8.49 (VSS), U8.74 (VSS), U8.99 (VSS), U10.7 (GND), U11.5 (GND), U12.5 (GND), Y2.2, Y2.4
HSE_IN: C5.2, U8.12 (PH0), Y2.1
HSE_OUT: C6.2, U8.13 (PH1), Y2.3
INT_BNO: U7.14 (INT), U8.57 (PD10)
INT_Mouse: Q15.3 (D), U10.6 (INT)
LED_B0: H3.1, R52.2, U8.87 (PD6)
LED_B1: H4.1, R53.2, U8.78 (PC10)
LED_LG0: R63.2, U8.92 (PB6)
LED_Y0: R67.2, U8.93 (PB7)
LED_nR0: Q18.1 (G), R69.1, U8.83 (PD2)
MISO2: U8.53 (PB14), U10.5 (MISO)
MOSI2: U8.54 (PB15), U10.4 (MOSI)
Main->INT_Mouse: Q15.1 (G), R59.1, U8.55 (PD8)
Main->RST_BNO: Q16.1 (G), R3.1, U8.62 (PD15)
MainRX1_RS485RingXTX: U4.1 (RO), U8.69 (PA10)
MainRX2_RS485MDTX: U6.1 (RO), U8.25 (PA3)
MainRX4_RS485RingYTX: U8.70 (PA11), U12.1 (RO)
MainTX1_RS485RingXRX: R34.2, U3.4 (DI), U8.68 (PA9)
MainTX2_RS485MDRX: R43.2, U5.4 (DI), U8.24 (PA2)
MainTX4_RS485RingYRX: R71.2, U8.71 (PA12), U11.4 (DI)
NRST: C2.1, J1.12, SW1.1 (A), U8.14 (NRST)
unnamed: C14.1, U8.48 (VCAP)
unnamed: C15.1, U8.73 (VCAP)
unnamed: C24.1, R28.2, R29.1
unnamed: D1.1 (K), J1.3, R62.1
unnamed: D5.1 (K), L1.1
unnamed: D7.2 (A), R31.1
unnamed: D8.2 (A), R32.1
unnamed: D9.2 (A), R33.1
unnamed: D10.2 (A), R52.1
unnamed: D11.2 (A), R53.1
unnamed: D12.2 (A), R63.1
unnamed: D13.2 (A), Q18.3 (D), R66.2
unnamed: D14.2 (A), R67.1
unnamed: J7.A5 (CC1), R65.2
unnamed: J7.B5 (CC2), R64.2
unnamed: JP4.2 (B), R50.1
unnamed: JP5.2 (B), R51.1
unnamed: C17.2, Q1.1 (G), R6.2
unnamed: Q2.1 (B), Q2.3 (C), Q4.1 (B), R9.2
unnamed: Q3.1 (G), Q4.3 (C), R13.2
unnamed: Q5.3 (D), Q6.1 (G), R14.2
unnamed: Q7.3 (G), R16.1, R18.2
unnamed: Q8.3 (D), R21.2
unnamed: C19.2, Q9.3 (G), R19.2, R21.1
unnamed: Q10.1 (B), Q10.3 (C), Q12.1 (B), R23.2
unnamed: Q11.1 (G), Q12.3 (C), R25.2
unnamed: Q13.1 (B), R34.1
unnamed: Q13.3 (C), R35.1, U3.2 (~RE), U3.3 (DE)
unnamed: Q14.1 (B), R43.1
unnamed: Q14.3 (C), R44.1, U5.2 (~RE), U5.3 (DE)
unnamed: Q17.1 (B), R71.1
unnamed: Q17.3 (C), R72.1, U11.2 (~RE), U11.3 (DE)
unnamed: R20.1, SW2.3 (C)
unnamed: R11.1, R12.2, U2.9 (FB)
unnamed: C11.1, R10.1, U2.8 (VCC), U2.11 (RT)
unnamed: R36.1, U4.2 (~RE), U4.3 (DE)
unnamed: R45.1, U6.2 (~RE), U6.3 (DE)
unnamed: R73.1, U12.2 (~RE), U12.3 (DE)
RST_BNO: Q16.3 (D), U7.11 (~RESET)
SCL4: R61.2, U7.19 (COM1), U8.59 (PD12)
SCLK2: U8.52 (PB13), U10.3 (SCK)
SDA4: R60.2, U7.20 (COM0), U8.60 (PD13)
SHDN/BOOT: C10.2, R68.1, SW5.1 (A), U8.61 (PD14)
SWCLK: J1.6, U8.76 (PA14(JTCK)
SWDIO: J1.4, U8.72 (PA13(JTMS)
SWO: J1.8, U8.89 (PB3(JTDO)
SlideSW0: R56.1, SW4.1 (A), U8.63 (PC6)
VBUS: C40.2, J7.A9 (VBUS), J7.B9 (VBUS), Q1.2 (S), R4.2
VCC: C16.1, C23.1, C38.1, D2.1 (K), L1.2, R26.1, U2.2 (EN), U2.3 (VIN)
VDD: C22.1, D4.1 (K), D5.2 (A), Q9.1 (D), Q9.2 (D), Q9.5 (D), Q9.6 (D), R24.1, R28.1
V_Meas.: R29.2, R30.1, U8.23 (PA1)
