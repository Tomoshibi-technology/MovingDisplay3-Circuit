# Repository Tomoshibi-technology/MovingDisplay3-Circuit (continued)

## KiCad design circuits/Imposition/2ndLayer_3rdLayer/2ndLayer_3rdLayer.kicad_pcb

Parts:
C12, C14, C34, C35, C36, C40: 0.1uF; C_0402_1005Metric
C37: 10uF; C_0805_2012Metric
C38, C39: 47pF; C_0603_1608Metric
J3: Conn_02x10_Odd_Even; PinHeader_2x10_P1.27mm_Vertical
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
R7, R12, R13, R14, R16, R19, R73, R80: 10k; R_0402_1005Metric
R74, R75: PullUP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R76, R77: 33; R_0603_1608Metric
R78, R79: 5.1k; R_0402_1005Metric
SW7, SW8, SW9: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW10: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW11: SW_SPDT; SW_Slide_DPDT_SSSS820101
U9: Display_Akzk_128x68OLED; Display_Aktk_128x68OLED_White
U10: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm

Connections:
/3rdLayer/3V3_3rdLayer: C12.1, C14.1, C34.1, C35.1, J3.3, R74.1, R75.1, SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.5, SW10.6, SW10.7, SW10.8, SW11.2 (B), U9.2 (VCC)
/3rdLayer/DIPSW0: J3.13, R7.2, SW10.1
/3rdLayer/DIPSW1: J3.15, R12.2, SW10.2
/3rdLayer/DIPSW2: J3.17, R13.2, SW10.3
/3rdLayer/DIPSW3: J3.19, R14.2, SW10.4
/3rdLayer/I2C_SCL: J3.9, R74.2, U9.3 (SCL)
/3rdLayer/I2C_SDA: J3.7, R75.2, U9.4 (SDA)
/3rdLayer/PRG_Twe: J3.11, U10.19 (CBUS3)
/3rdLayer/RST_Twe: J3.8, U10.10 (CBUS2)
/3rdLayer/SlideSW1: J3.10, R80.1, SW11.1 (A)
/3rdLayer/TactSW0: C12.2, J3.16, R16.1, SW7.1 (A)
/3rdLayer/TactSW1: C14.2, J3.14, R19.1, SW8.1 (A)
/3rdLayer/TactSW2: C34.2, J3.12, R73.1, SW9.1 (A)
/3rdLayer/TweWriteRX_TweTX: J3.20, U10.4 (RXD)
/3rdLayer/TweWriteTX_TweRX: J3.18, U10.20 (TXD)
/3rdLayer/VBUS_3rdLayer: C36.1, C37.2, J3.1, J3.2, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), U10.15 (VCC)
GND: C35.2, C36.2, C37.1, C38.2, C39.2, C40.1, J3.4, J3.5, J3.6, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), R7.1, R12.1, R13.1, R14.1, R16.2, R19.2, R73.2, R78.1, R79.1, R80.2, SW11.4 (shell), SW11.5 (shell), SW11.6 (shell), SW11.G1 (shell), SW11.G2 (shell), SW11.G3 (shell), SW11.G4 (shell), U9.1 (GND), U10.6 (GND), U10.16 (GND); also elsewhere on the board
unnamed: C38.1, J4.A7 (D-), J4.B7 (D-), R77.2
unnamed: C39.1, J4.A6 (D+), J4.B6 (D+), R76.2
unnamed: J4.A5 (CC1), R79.2
unnamed: J4.B5 (CC2), R78.2
unnamed: C40.2, U10.3 (VCCIO), U10.13 (3V3OUT), U10.14 (~RESET)
unnamed: R77.1, U10.12 (USBDM)
unnamed: R76.1, U10.11 (USBDP)

Notes on the sheet:
モニター用タクトスイッチ
スライドスイッチ
OLED
モニター
DIPスイッチ
USB-C
PinHeader

Parts:
C1, C2, C3, C6, C7, C8, C41: 0.1uF; C_0402_1005Metric
C4, C5: 22pF; C_0603_1608Metric
C25: 4.7uF; C_0603_1608Metric
C27: 1uF; C_0402_1005Metric
C30, C31: 2.2uF; C_0402_1005Metric
D1: 1N5819WS; Diode_SOD-323
J1: Conn_01x10_Pin; PinHeader_1x10_P1.27mm_Vertical
J2: Conn_02x10_Odd_Even; PinSocket_2x10_P1.27mm_Vertical
Q16: 2N7002; SOT-23
R1: 1k; R_0402_1005Metric
R2, R67: 10k; R_0402_1005Metric
SW2: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U8: STM32H723VGTx; LQFP-100_14x14mm_P0.5mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C3.1, C6.1, C7.1, C8.1, C25.1, C27.1, C41.1, D1.2 (A), J2.3, U8.6 (VBAT), U8.11 (VDD), U8.20 (VREF+), U8.21 (VDDA), U8.27 (VDD), U8.50 (VDD), U8.75 (VDD), U8.100 (VDD); also elsewhere on the board
/2ndLayer/BOOT0: R2.1, U8.94 (BOOT0)
/2ndLayer/DIPSW0: U8.33 (PC5); also elsewhere on the board
/2ndLayer/DIPSW0_Twe: J2.13; also elsewhere on the board
/2ndLayer/DIPSW1: U8.34 (PB0); also elsewhere on the board
/2ndLayer/DIPSW1_Twe: J2.15; also elsewhere on the board
/2ndLayer/DIPSW2: U8.37 (PE7); also elsewhere on the board
/2ndLayer/DIPSW2_Twe: J2.17; also elsewhere on the board
/2ndLayer/DIPSW3: U8.38 (PE8); also elsewhere on the board
/2ndLayer/DIPSW3_Twe: J2.19; also elsewhere on the board
/2ndLayer/HSE_IN: C4.2, U8.12 (PH0), Y1.1
/2ndLayer/HSE_OUT: C5.2, U8.13 (PH1), Y1.3
/2ndLayer/LED_B0: U8.1 (PE2); also elsewhere on the board
/2ndLayer/LED_B1: U8.4 (PE5); also elsewhere on the board
/2ndLayer/LED_LG0: U8.91 (PB5); also elsewhere on the board
/2ndLayer/LED_Y0: U8.86 (PD5); also elsewhere on the board
/2ndLayer/LED_nR0: U8.97 (PE0); also elsewhere on the board
/2ndLayer/Main->RST_Twe: Q16.1 (G), R67.1, U8.46 (PB10)
/2ndLayer/MainRX1_TweTX1: U8.69 (PA10); also elsewhere on the board
/2ndLayer/MainRX3_RS485YTX: U8.79 (PC11); also elsewhere on the board
/2ndLayer/MainRX4_RS485XTX: U8.81 (PD0); also elsewhere on the board
/2ndLayer/MainTX1_TweRX1: U8.68 (PA9); also elsewhere on the board
/2ndLayer/MainTX3_RS485YRX: U8.78 (PC10); also elsewhere on the board
/2ndLayer/MainTX4_RS485XRX: U8.82 (PD1); also elsewhere on the board
/2ndLayer/NRST: C2.1, J1.10, SW2.1 (A), U8.14 (NRST)
/2ndLayer/PRG_Twe: J2.11; also elsewhere on the board
/2ndLayer/RST_Twe: J2.8, Q16.3 (D); also elsewhere on the board
/2ndLayer/SCL4: J2.9, U8.59 (PD12)
/2ndLayer/SDA4: J2.7, U8.60 (PD13)
/2ndLayer/SWCLK: J1.6, U8.76 (PA14(JTCK)
/2ndLayer/SWDIO: J1.4, U8.72 (PA13(JTMS)
/2ndLayer/SWO: J1.8, U8.89 (PB3(JTDO)
/2ndLayer/SlideSW0: U8.32 (PC4); also elsewhere on the board
/2ndLayer/SlideSW1: J2.10, U8.42 (PE12)
/2ndLayer/TactSW0: J2.16, U8.45 (PE15)
/2ndLayer/TactSW1: J2.14, U8.44 (PE14)
/2ndLayer/TactSW2: J2.12, U8.43 (PE13)
/2ndLayer/TweWriteRX_TweTX0: J2.20; also elsewhere on the board
/2ndLayer/TweWriteTX_TweRX0: J2.18; also elsewhere on the board
/2ndLayer/V_Meas.: U8.35 (PB1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C8.2, C25.2, C27.2, C30.2, C31.2, C41.2, J1.1, J1.3, J1.5, J1.7, J1.9, J2.4, J2.5, J2.6, Q16.2 (S), R1.2, R2.2, R67.2, SW2.2 (B), U8.10 (VSS), U8.19 (VSSA), U8.26 (VSS), U8.49 (VSS), U8.74 (VSS), U8.99 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: C30.1, U8.48 (VCAP)
unnamed: C31.1, U8.73 (VCAP)
unnamed: D1.1 (K), J1.2, R1.1
VBUS: J2.1, J2.2; also elsewhere on the board

Notes on the sheet:
BOOT0
H723VG
書き込み
パスコン
NRST
Main to TweLite Reset
マイコン
HSE

Parts:
C11, C18, C20, C23: 0.1uF; C_0402_1005Metric
J10, J11: Conn_01x06_MountingPin; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
Q13, Q14: S8550; SOT-23
R4, R48: 7.5k; R_0603_1608Metric
R5, R49: 20k; R_0402_1005Metric
R36, R50: 10k; R_0402_1005Metric
R42, R43, R44, R45, R51, R52, R53, R54: 2.2k; R_0402_1005Metric
R46, R47, R55, R56: 120; R_0402_1005Metric
U3, U4, U5, U6: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C11.1, C18.1, C20.1, C23.1, Q13.2 (E), Q14.2 (E), R42.1, R44.1, R51.1, R53.1, U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U6.8 (VCC); also elsewhere on the board
+BATT: J10.2, J11.2; also elsewhere on the board
/2ndLayer/MainRX3_RS485YTX: U6.1 (RO); also elsewhere on the board
/2ndLayer/MainRX4_RS485XTX: U4.1 (RO); also elsewhere on the board
/2ndLayer/MainTX3_RS485YRX: R48.2, U5.4 (DI); also elsewhere on the board
/2ndLayer/MainTX4_RS485XRX: R4.2, U3.4 (DI); also elsewhere on the board
/2ndLayer/RS485_RingNW/RS485X_RA: J10.5, R44.2, R47.1, U4.6 (A)
/2ndLayer/RS485_RingNW/RS485X_RB: J10.6, R45.1, R47.2, U4.7 (B)
/2ndLayer/RS485_RingNW/RS485X_TA: J10.3, R42.2, R46.1, U3.6 (A)
/2ndLayer/RS485_RingNW/RS485X_TB: J10.4, R43.1, R46.2, U3.7 (B)
/2ndLayer/RS485_RingNW/RS485Y_RA: J11.5, R53.2, R56.1, U6.6 (A)
/2ndLayer/RS485_RingNW/RS485Y_RB: J11.6, R54.1, R56.2, U6.7 (B)
/2ndLayer/RS485_RingNW/RS485Y_TA: J11.3, R51.2, R55.1, U5.6 (A)
/2ndLayer/RS485_RingNW/RS485Y_TB: J11.4, R52.1, R55.2, U5.7 (B)
GND: C11.2, C18.2, C20.2, C23.2, J10.1, J10.MP (MountPin), J11.1, J11.MP (MountPin), R5.2, R36.2, R43.2, R45.2, R49.2, R50.2, R52.2, R54.2, U3.5 (GND), U4.5 (GND), U5.5 (GND), U6.5 (GND); also elsewhere on the board
unnamed: Q13.1 (B), R4.1
unnamed: Q13.3 (C), R5.1, U3.2 (~RE), U3.3 (DE)
unnamed: Q14.1 (B), R48.1
unnamed: Q14.3 (C), R49.1, U5.2 (~RE), U5.3 (DE)
unnamed: R36.1, U4.2 (~RE), U4.3 (DE)
unnamed: R50.1, U6.2 (~RE), U6.3 (DE)

Notes on the sheet:
RS485_RingNW_X
RS485_RingNW_Y
MAX3485_Tx(3,4Pin)
MAX3485_Rx(5,6Pin)
Conn

Parts:
C9: 10uF; C_1206_3216Metric
C10, C32: 22uF; C_0805_2012Metric
C13: ADJ_ST; C_0603_1608Metric
C15, C16, C17, C33: 1uF; C_0402_1005Metric
C21: 47uF; CP_Elec_6.3x5.4
C22: 0.1uF; C_0603_1608Metric
D4, D6, D17: 1N5819WS; Diode_SOD-323
D5: SS2040FL; D_SOD-123
D7, D8, D9: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L1: 1uH; L_0603_1608Metric
Q1, Q3, Q11, Q17: SSM3J332R; SOT-23W
Q2, Q4, Q10, Q12: S8550; SC-59
Q7, Q9: SSM6J808R; Package_TSOP6F
Q8, Q18: 2N7002; SC-59
R3, R8, R10, R11, R15, R17, R18, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R70, R71: 10k; R_0402_1005Metric
R6, R9, R33, R34, R35: 1k; R_0402_1005Metric
R30: 1k; R_0603_1608Metric
R31: 75k; R_0603_1608Metric
R32: 10k; R_0603_1608Metric
R69: 20k; R_0402_1005Metric
R72: 5.1k; R_0402_1005Metric
SW1: SW_SPDT_White; SW_Slide_SPDT_IS-1235-G
TP1: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: DCDC_TPSM336x5
U7: AZ1117CH-3.3; SOT-223-3_TabPin2

Connections:
+3.3V: C17.1, D6.2 (A), R29.2, R35.2, U7.2 (VO); also elsewhere on the board
+5V: C16.1, D6.1 (K), Q3.2 (S), Q4.2 (E), Q11.2 (S), Q12.2 (E), R17.2, R34.2, U7.3 (VI)
+BATT: Q7.1 (D), Q7.2 (D), Q7.5 (D), Q7.6 (D); also elsewhere on the board
/2ndLayer/Power/IND: Q1.3 (D), Q2.2 (E), Q3.3 (D), R10.2, R33.2
/2ndLayer/Power/PG: Q18.1 (G), R70.2, U1.1 (PGOOD)
/2ndLayer/Power/PowerSW: Q8.1 (G), R22.2, R24.1, SW1.3 (C)
/2ndLayer/Power/S-S: C15.1, Q7.4 (S), Q9.4 (S), R20.1, R21.1, R22.1
/2ndLayer/Power/VSYS: Q10.2 (E), Q11.3 (D), Q17.3 (D), R71.2
/2ndLayer/Power/Vout: C10.1, C32.1, D17.2 (A), Q17.2 (S), R3.1, R8.1, R9.1, R69.2, U1.4 (VOUT)
/2ndLayer/V_Meas.: R31.2, R32.1; also elsewhere on the board
GND: C9.2, C10.2, C13.1, C16.2, C17.2, C21.2, C22.2, C32.2, C33.2, D4.2 (A), D7.1 (K), D8.1 (K), D9.1 (K), Q8.2 (S), Q18.2 (S), R6.1, R9.2, R10.1, R11.1, R15.1, R17.1, R18.2, R24.2, R25.1, R26.2, R27.1, R28.2, R29.1, R32.2, R71.1, R72.1, SW1.2 (B), TP1.1, U1.10 (GND), U7.1 (GND); also elsewhere on the board
unnamed: C22.1, R30.2, R31.1
unnamed: D5.1 (K), L1.1
unnamed: D7.2 (A), R33.1
unnamed: D8.2 (A), R34.1
unnamed: D9.2 (A), R35.1
unnamed: C13.2, Q1.1 (G), R8.2
unnamed: Q2.1 (B), Q2.3 (C), Q4.1 (B), R11.2
unnamed: Q3.1 (G), Q4.3 (C), R15.2
unnamed: Q7.3 (G), R18.1, R20.2
unnamed: Q8.3 (D), R23.2
unnamed: C15.2, Q9.3 (G), R21.2, R23.1
unnamed: Q10.1 (B), Q10.3 (C), Q12.1 (B), R25.2
unnamed: Q11.1 (G), Q12.3 (C), R27.2
unnamed: Q17.1 (G), Q18.3 (D), R3.2
unnamed: R69.1, R72.2, U1.9 (FB)
unnamed: C33.1, R70.1, U1.8 (VCC), U1.11 (RT)
VBUS: Q1.2 (S), R6.2; also elsewhere on the board
VCC: C9.1, C21.1, D17.1 (K), L1.2, R28.1, U1.2 (EN), U1.3 (VIN)
VDD: D4.1 (K), D5.2 (A), Q9.1 (D), Q9.2 (D), Q9.5 (D), Q9.6 (D), R26.1, R30.1

Notes on the sheet:
5V生成
電源切替/USB
電源電圧測定
3.3V生成
主電源スイッチ
理想ダイオード/5VSYS
保護回路・スイッチ
TestPoint
Capacitor
インジケーターLED
PowerModule

Parts:
D12, D13: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D14: LightGreen; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D15: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D16: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2: MountingHole_Pad; TestPoint_Pad_1.0x1.0mm
Q15: 2N7002; SOT-23
R57, R58, R65, R68: 1k; R_0402_1005Metric
R59, R60, R61, R62, R63, R64: 10k; R_0402_1005Metric
R66: 1k; R_0603_1608Metric
SW5: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW6: SW_SPDT; SW_Slide_SPDT_SSAJ120100

Connections:
+3.3V: R68.1, SW5.5, SW5.6, SW5.7, SW5.8, SW6.2 (B); also elsewhere on the board
/2ndLayer/DIPSW0: R59.2, SW5.1; also elsewhere on the board
/2ndLayer/DIPSW1: R60.2, SW5.2; also elsewhere on the board
/2ndLayer/DIPSW2: R62.2, SW5.3; also elsewhere on the board
/2ndLayer/DIPSW3: R63.2, SW5.4; also elsewhere on the board
/2ndLayer/LED_B0: H1.1, R57.2; also elsewhere on the board
/2ndLayer/LED_B1: H2.1, R58.2; also elsewhere on the board
/2ndLayer/LED_LG0: R65.2; also elsewhere on the board
/2ndLayer/LED_Y0: R66.2; also elsewhere on the board
/2ndLayer/LED_nR0: Q15.1 (G), R64.1; also elsewhere on the board
/2ndLayer/SlideSW0: R61.1, SW6.3 (C); also elsewhere on the board
GND: D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), Q15.2 (S), R59.1, R60.1, R61.2, R62.1, R63.1, R64.2, SW6.4 (shell), SW6.5 (shell); also elsewhere on the board
unnamed: D12.2 (A), R57.1
unnamed: D13.2 (A), R58.1
unnamed: D14.2 (A), R65.1
unnamed: D15.2 (A), R66.1
unnamed: D16.2 (A), Q15.3 (D), R68.2

Notes on the sheet:
LED
Error
I/O
DIPスイッチ
not Running
Indicator
Running
スライドスイッチ

Parts:
C28: 0.1uF; C_0402_1005Metric
C29: 1uF; C_0402_1005Metric
D10, D11: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R37, R38: PullUP?; R_0402_1005Metric
R39, R40: 1k; R_0603_1608Metric
R41: PullUP?; R_0603_1608Metric
SW3, SW4: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U2: TWE-L-WX; MonoWireless_TWE-L-WX

Connections:
+3.3V: C29.2, R37.1, R38.1, R41.2, U2.5 (VCC); also elsewhere on the board
/2ndLayer/DIPSW0_Twe: U2.3 (DIO18/DO1); also elsewhere on the board
/2ndLayer/DIPSW1_Twe: U2.4 (DIO19/DO2); also elsewhere on the board
/2ndLayer/DIPSW2_Twe: U2.6 (DIO4/DO3); also elsewhere on the board
/2ndLayer/DIPSW3_Twe: U2.7 (DIO5/PWM1); also elsewhere on the board
/2ndLayer/MainRX1_TweTX1: U2.14 (DIO14/SCL); also elsewhere on the board
/2ndLayer/MainTX1_TweRX1: U2.17 (DIO15/SDA); also elsewhere on the board
/2ndLayer/PRG_Twe: R37.2, SW4.1 (A), U2.2 (DO1/PWM3); also elsewhere on the board
/2ndLayer/RST_Twe: C28.1, R38.2, SW3.1 (A), U2.21 (~RESET); also elsewhere on the board
/2ndLayer/TweLite/LED_B0: R39.2, U2.16 (DIO11/DI3)
/2ndLayer/TweLite/LED_B1: R40.2, U2.15 (DIO13/DI2)
/2ndLayer/TweLite/SET: U2.13 (DIO12/DI1)
/2ndLayer/TweWriteRX_TweTX0: U2.8 (DIO6/TX); also elsewhere on the board
/2ndLayer/TweWriteTX_TweRX0: U2.9 (DIO7/RX); also elsewhere on the board
GND: C28.2, C29.1, D10.1 (K), D11.1 (K), SW3.2 (B), SW4.2 (B), U2.20 (GND), U2.22 (ADC2/AI3), U2.23 (ADC1/AI1), U2.28 (GND), U2.30 (GND), U2.31 (GND), U2.32 (GND); also elsewhere on the board
unnamed: D10.2 (A), R39.1
unnamed: D11.2 (A), R40.1
unnamed: R41.1, U2.1 (DO0/PWM2)

Notes on the sheet:
TweLite
PRG
リセット
LED
