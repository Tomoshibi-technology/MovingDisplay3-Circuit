# Repository Tomoshibi-technology/MovingDisplay3-Circuit (continued)

## KiCad design circuits/Imposition/2ndLayer_3rdLayer/2ndLayer_3rdLayer.kicad_pcb (continued)

Board: 2 copper layers, 53.9 x 71.7 mm, 181 parts (146 on the bottom side), 118 nets.

## KiCad design circuits/RasPi/RasPi.kicad_pcb

Board: 4 copper layers, 90.0 x 57.0 mm, 304 parts (231 on the bottom side), 193 nets.

Parts:
C1, C2, C3, C6, C7, C8, C11, C12, C13, C14, C22, C28, C31, C33, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C46, C51, C52, C54, C56, C60, C61: 0.1uF; C_0402_1005Metric
C4, C5: 22pF; C_0603_1608Metric
C9, C18, C26, C49, C66, C67: 100uF; C_1206_3216Metric
C10, C16, C17: 10uF; C_1206_3216Metric
C15, C23, C24, C25, C63: 1uF; C_0402_1005Metric
C19, C62: 2.2uF; C_0402_1005Metric
C20: 4.7uF; C_0603_1608Metric
C21: ADJ_ST; C_0603_1608Metric
C30: 0.1uF; C_0603_1608Metric
C45, C48, C55, C68: 10uF; C_0805_2012Metric
C47, C50, C70: 15pF; C_0402_1005Metric
C53, C64: 22uF; C_0805_2012Metric
C57: 10nF; C_0402_1005Metric
C58, C59: 47pF; C_0603_1608Metric
C65: 4.7nF; C_0402_1005Metric
D1, D4, D6, D8: 1N5819WS; D_SOD-323_HandSoldering
D2, D3, D12, D13, D14, D15, D19, D28: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D16, D18: D_Zener; D_SOD-323_HandSoldering
D7, D27: SS2040FL; D_SOD-123
D9, D10, D11, D23: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D17: MA10EB045; Vishay_SMPA
D20, D29: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D21, D24, D26: LightGreen; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D22, D25: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole_Pad; TestPoint_Pad_1.0x1.0mm
J1: Conn_01x14_Pin; BoxHeader_2x07_P1.27mm_Horizontal
J2, J3: Conn_01x06_MountingPin; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
J4: Conn_01x02_Pin; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J5: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J6: Conn_01x03_MountingPin; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
J7: RJ45_LPJK7001AGNL; Connector_RJ45_LPJK7001AGNL
J9: Conn_01x04_MountingPin; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
J10: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J11: Micro_SD_Card_Det_Hirose_DM3AT; Connector_SDCard_DM3AT
J12, J14: Conn_01x02_MountingPin; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal
J13: Conn_01x03_MountingPin; Molex_PicoBlade_53398-0371_1x03-1MP_P1.25mm_Vertical
J15: Conn_01x08_MountingPin; Molex_PicoBlade_53261-0871_1x08-1MP_P1.25mm_Horizontal
L1: 1uH; L_0603_1608Metric
L2: 3.3uH; Inductor_ECS-MPIL0530
L4: 1uH; L_1210_3225Metric
Q1, Q2, Q3, Q4, Q5, Q7, Q9, Q15, Q17, Q18, Q19, Q22: S8550; SOT-23
Q6, Q8, Q26, Q28: SSM3J332R; SOT-23W
Q10, Q11, Q13, Q20, Q21, Q23, Q24, Q25, Q27: 2N7002; SOT-23
Q12, Q14, Q16, Q29: SSM6J808R; TSOP-6_1.65x3.05mm_P0.95mm
R1, R3, R4, R5, R42, R44, R47, R71, R72, R73, R80, R81, R82, R83, R107, R108, R109, R111, R112, R113, R114, R120: 1k; R_0402_1005Metric
R2, R6, R7, R8, R9, R10, R16, R20, R45, R46, R48, R49, R50, R53, R55, R56, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R84, R88, R89, R91, R92, R102, R103, R104, R105, R106, R110, R117: 10k; R_0402_1005Metric
R11, R24, R28, R30, R37, R41, R57, R77, R90: 7.5k; R_0603_1608Metric
R12, R25, R31, R34, R38, R74, R78, R95: 20k; R_0402_1005Metric
R13, R14, R17, R18, R21, R22, R26, R27, R32, R33, R35, R36, R39, R40, R75, R76, R79, R87, R96, R97, R122: 2.2k; R_0402_1005Metric
R15, R19, R23, R98: 120; R_0402_1005Metric
R29, R51, R52, R85, R86: 5.1k; R_0402_1005Metric
R43: 2k; R_0402_1005Metric
R54: 100k; R_0603_1608Metric
R68: 1k; R_0603_1608Metric
R69: 75k; R_0603_1608Metric
R70: 10k; R_0603_1608Metric
R93, R94: 470; R_0402_1005Metric
R99: 13k; R_0603_1608Metric
R100: 1.8k; R_0603_1608Metric
R101, R115: 33; R_0603_1608Metric
R116, R121: 22k; R_0402_1005Metric
R118: 5.1k; R_0603_1608Metric
R119, R124: 100k; R_0402_1005Metric
R123: 2k; R_0603_1608Metric
SW1: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
SW3, SW6: SW_SPDT; SW_Slide_SPDT_SSSS213202
SW4: SW_SPDT; SW_Slide_SPDT_IS-1235-G
SW5: SW_SPDT; SW_Slide_3P_SPDT
SW7: SW_SPST; SW_SPST_Omron_B3FS-100xP
TP1, TP2, TP3: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: SBC_RPi-CM4
U2, U3, U4, U5, U8, U9, U10, U11, U12, U14: MAX3485; SOP-8_3.9x4.9mm_P1.27mm
U6: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm
U7: FPGA_TangPrimer25K_Core
U13: TPS54560BDDA; Texas_R-PDSO-G8_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias
U15: STM32H723VGTx; LQFP-100_14x14mm_P0.5mm
U16: AZ1117CH-3.3; SOT-223-3_TabPin2
U17, U20: M51957B; SOP-8_3.9x4.9mm_P1.27mm
U18: DAC_PT8211S; SOP-8_3.9x4.9mm_P1.27mm
U19: DCDC_TPS61023
U21: 74AHC1G02; SOT-23-5
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C3.1, C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C14.1, C20.1, C22.1, C25.1, C28.1, C31.1, C33.1, C35.1, C36.1, C38.1, C63.1, D1.2 (A), D8.2 (A), J7.14, J7.16, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q18.2 (E), Q19.2 (E), Q22.2 (E), Q28.2 (S), R13.1, R17.1, R21.1, R26.1, R32.1, R35.1, R39.1, R67.2, R73.2, R75.1, R79.1, R96.1, R104.2, R106.2, R109.1, R113.1, R114.2, R120.1, SW2.5, SW2.6, SW2.7, SW2.8, SW3.2 (B), SW6.2 (B), TP2.1, U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U5.8 (VCC), U8.8 (VCC), U9.8 (VCC), U10.8 (VCC), U11.8 (VCC), U12.8 (VCC), U14.8 (VCC), U15.6 (VBAT), U15.11 (VDD), U15.20 (VREF+), U15.21 (VDDA), U15.27 (VDD), U15.50 (VDD), U15.75 (VDD), U15.100 (VDD), U16.2 (VO)
+5V: C15.1, C24.1, C37.1, C39.1, C40.1, C41.1, C42.1, C44.1, C52.2, C53.1, C54.1, C56.2, C64.1, D5.1 (K), D8.1 (K), J6.2, J9.2, Q8.2 (S), Q9.2 (E), Q16.1 (D), Q16.2 (D), Q16.5 (D), Q16.6 (D), Q17.2 (E), Q26.2 (S), R55.2, R72.2, R102.2, TP1.1, U1.77 (+5V(INPUT)), U1.79 (+5V(INPUT)__1), U1.81 (+5V(INPUT)__2), U1.83 (+5V(INPUT)__3), U1.85 (+5V(INPUT)__4), U1.87 (+5V(INPUT)__5), U7.A52 (VDD_5V), U7.A54 (VDD_5V), U7.A56 (VDD_5V), U7.A58 (VDD_5V), U7.A60 (VDD_5V), U16.3 (VI), U17.7 (VCC), U18.5 (VDD), U20.7 (VCC)
+BATT: J2.2, J3.2, Q12.1 (D), Q12.2 (D), Q12.5 (D), Q12.6 (D)
/DSI_CK_N: U1.187 (DSI1_C_N), U7.A45 (M0_CK_N)
/DSI_CK_P: U1.189 (DSI1_C_P), U7.A43 (M0_CK_P)
/DSI_D0_N: U1.175 (DSI1_D0_N), U7.A57 (M0_D0_N)
/DSI_D0_P: U1.177 (DSI1_D0_P), U7.A55 (M0_D0_P)
/DSI_D1_N: U1.181 (DSI1_D1_N), U7.A51 (M0_D1_N)
/DSI_D1_P: U1.183 (DSI1_D1_P), U7.A49 (M0_D1_P)
/DSI_D2_N: U1.193 (DSI1_D2_N), U7.A39 (M0_D2_N)
/DSI_D2_P: U1.195 (DSI1_D2_P), U7.A37 (M0_D2_P)
/DSI_D3_N: U1.194 (DSI1_D3_N), U7.A33 (M0_D3_N)
/DSI_D3_P: U1.196 (DSI1_D3_P), U7.A31 (M0_D3_P)
/FPGA_TangPrimerCore/3.3V_TangPrimer: R85.2, R86.2, U7.A2 (VCCIO2/3), U7.A4 (VCCIO2/3), U7.A46 (VDD_3V3), U7.A48 (VDD_3V3), U7.A50 (VDD_3V3), U7.B24 (VCCIO0/1), U7.B26 (VCCIO0/1), U7.B29 (VCCIO6/7), U7.B31 (VCCIO6/7)
/FPGA_TangPrimerCore/DAC/LCH_OUT: J12.2, U18.6 (LCH)
/FPGA_TangPrimerCore/DAC/RCH_OUT: J14.2, U18.8 (RCH)
/FPGA_TangPrimerCore/LED_B0: H1.1, R80.2
/FPGA_TangPrimerCore/LED_B1: H2.1, R81.2
/FPGA_TangPrimerCore/LED_B2: H3.1, R82.2
/FPGA_TangPrimerCore/LED_B3: H4.1, R83.2
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel0: J15.2, U5.6 (A)
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel1: J15.3, U8.6 (A)
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel2: J15.4, U9.6 (A)
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel3: J15.5, U10.6 (A)
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel4: J15.6, U11.6 (A)
/FPGA_TangPrimerCore/RS485_Panel/RS485_Panel5: J15.7, U12.6 (A)
/FPGA_TangPrimerCore/SlideSW0: R84.1, SW6.1 (A)
/FPGA_TangPrimerCore/TCK: J5.2, R29.1, U7.A21 (C1_TCK)
/FPGA_TangPrimerCore/TDI: J5.5, U7.A27 (A3_TDI)
/FPGA_TangPrimerCore/TDO: J5.4, U7.A25 (A2_TDO)
/FPGA_TangPrimerCore/TMS: J5.3, U7.A23 (B1_TMS)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel0RX: R24.2, U5.4 (DI)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel1RX: R30.2, U8.4 (DI)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel2RX: R28.2, U9.4 (DI)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel3RX: R37.2, U10.4 (DI)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel4RX: R41.2, U11.4 (DI)
/FPGA_TangPrimerCore/TangPrimerTXx_Panel5RX: R77.2, U12.4 (DI)
/MCU->RasPi_GPIO3: Q13.1 (G), R88.1
/Power/Cap: C55.2, C68.2, D16.2 (A), D27.2 (A), J4.2, L4.2, R45.2, R124.2, U19.3 (VIN)
/Power/EN_Boost: R124.1, U19.2 (EN)
/Power/FB_Boost: C57.2, R99.1, R100.2, U19.1 (FB)
/Power/FB_Buck: R43.2, R121.1, U13.5 (FB)
/Power/IND: Q6.3 (D), Q7.2 (E), Q8.3 (D), R48.2, R71.2
/Power/PowerSW: Q11.1 (G), R60.2, R62.1
/Power/S-S: C23.1, Q12.4 (S), Q14.4 (S), R58.1, R59.1, SW4.2 (B)
/Power/VSYS: C9.1, C18.1, C26.1, C49.1, C57.1, C66.1, C67.1, D4.2 (A), D27.1 (K), L2.2, Q15.2 (E), Q16.4 (S), Q29.4 (S), R50.2, R99.2, R121.2, U19.6 (VOUT)
/Power/Vout: R46.1, R47.1
/RST_FPGA: Q21.3 (D), U7.A13 (D8_RECONFIG)
/RasPi->RST_FPGA: Q21.1 (G), R89.1
/RasPi_CM4/ETH_LEDG: R94.1, U1.17 (ETHERNET_~LED2)
/RasPi_CM4/ETH_LEDY: R93.1, U1.15 (ETHERNET_~LED3)
/RasPi_CM4/FAN_PWRCtrl: Q25.1 (G), R103.2
/RasPi_CM4/GLOBAL_EN: SW5.3 (C), U1.99 (GLOBAL_EN)
/RasPi_CM4/LED_B0: H7.1, R3.2
/RasPi_CM4/LED_B1: H8.1, R42.2
/RasPi_CM4/LED_nACT: D26.1 (K), U1.21 (PI_~LED_ACTIVITY)
/RasPi_CM4/LED_nPWR: Q24.1 (G), R110.1, U1.95 (PI_LED_~PWR)
/RasPi_CM4/LED_nR0: Q23.1 (G), R117.1
/RasPi_CM4/LiDAR_PWM: J6.3, U1.80 (SCL0)
/RasPi_CM4/RasPiRX0_SerialTX: U1.51 (GPIO15), U6.20 (TXD)
/RasPi_CM4/RasPiRX5_LiDARTX: J9.4, U1.28 (GPIO13)
/RasPi_CM4/RasPiTX0_SerialRX: U1.55 (GPIO14), U6.4 (RXD)
/RasPi_CM4/RasPiTX5_LiDARRX: J9.3, U1.31 (GPIO12)
/RasPi_CM4/SD_CLK: J11.5 (CLK), U1.57 (SD_CLK)
/RasPi_CM4/SD_CMD: J11.3 (CMD), U1.62 (SD_CMD)
/RasPi_CM4/SD_Card/PWR: C45.2, J11.4 (VDD), Q28.3 (D)
/RasPi_CM4/SD_DAT0: J11.7 (DAT0), U1.63 (SD_DAT0)
/RasPi_CM4/SD_DAT1: J11.8 (DAT1), U1.67 (SD_DAT1)
/RasPi_CM4/SD_DAT2: J11.1 (DAT2), U1.69 (SD_DAT2)
/RasPi_CM4/SD_DAT3: J11.2 (DAT3/CD), U1.61 (SD_DAT3)
/RasPi_CM4/SD_PWR_ON: Q27.1 (G), R106.1, U1.75 (SD_PWR_ON)
/RasPi_CM4/TRD0_N: J7.10 (TD-), U1.10 (ETHERNET_PAIR0_N)
/RasPi_CM4/TRD0_P: J7.12 (TD+), U1.12 (ETHERNET_PAIR0_P)
/RasPi_CM4/TRD1_N: J7.6 (RD-), U1.6 (ETHERNET_PAIR1_N)
/RasPi_CM4/TRD1_P: J7.4 (RD+), U1.4 (ETHERNET_PAIR1_P)
/RasPi_GPIO3: C43.1, Q13.3 (D), SW7.1 (A), U1.56 (GPIO3)
/RasPi_SHDN: Q20.3 (D), R92.2
/ResetIC->RasPi_SHDN: Q20.1 (G), R91.1, U17.6 (OUT), U20.6 (OUT)
/RingNW/BOOT0: R2.1, U15.94 (BOOT0)
/RingNW/DIPSW0: R6.2, SW2.1
/RingNW/DIPSW1: R7.2, SW2.2
/RingNW/DIPSW2: R9.2, SW2.3
/RingNW/DIPSW3: R10.2, SW2.4
/RingNW/H723TXx_RS485XRX: R11.2, U2.4 (DI)
/RingNW/H723TXx_RS485YRX: R90.2, U14.4 (DI)
/RingNW/HSE_IN: C4.2, U15.12 (PH0), Y1.1
/RingNW/HSE_OUT: C5.2, U15.13 (PH1), Y1.3
/RingNW/LED_B0: H5.1, R4.2
/RingNW/LED_B1: H6.1, R5.2
/RingNW/LED_nR0: Q10.1 (G), R105.1
/RingNW/NRST: C2.1, J1.12, SW1.1 (A), U15.14 (NRST)
/RingNW/RS485_RingNW/RS485X_RA: J2.5, R17.2, R19.1, U3.6 (A)
/RingNW/RS485_RingNW/RS485X_RB: J2.6, R18.1, R19.2, U3.7 (B)
/RingNW/RS485_RingNW/RS485X_TA: J2.3, R13.2, R15.1, U2.6 (A)
/RingNW/RS485_RingNW/RS485X_TB: J2.4, R14.1, R15.2, U2.7 (B)
/RingNW/RS485_RingNW/RS485Y_RA: J3.5, R21.2, R23.1, U4.6 (A)
/RingNW/RS485_RingNW/RS485Y_RB: J3.6, R22.1, R23.2, U4.7 (B)
/RingNW/RS485_RingNW/RS485Y_TA: J3.3, R96.2, R98.1, U14.6 (A)
/RingNW/RS485_RingNW/RS485Y_TB: J3.4, R97.1, R98.2, U14.7 (B)
/RingNW/SWCLK: J1.6, U15.76 (PA14(JTCK)
/RingNW/SWDIO: J1.4, U15.72 (PA13(JTMS)
/RingNW/SWO: J1.8, U15.89 (PB3(JTDO)
/RingNW/SlideSW0: R8.1, SW3.1 (A)
/V_Meas.: R69.2, R70.1
CM4_1.8V(OUTPUT)__1: U1.88 (CM4_1.8V(OUTPUT)), U1.90 (CM4_1.8V(OUTPUT)__1)
CM4_3.3V(OUTPUT)__1: R92.1, U1.78 (GPIO_VREF), U1.84 (CM4_3.3V(OUTPUT)), U1.86 (CM4_3.3V(OUTPUT)__1)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C24.2, C25.2, C26.2, C28.2, C30.2, C31.2, C33.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.1, C46.2, C47.2, C48.1, C49.2, C50.2, C52.1, C53.2, C54.2, C55.1, C56.1, C58.2, C59.2, C60.1, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.1, C70.2, D2.1 (K), D3.1 (K), D5.2 (A), D6.2 (A), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D17.2 (A), D18.2 (A), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D28.1 (K), D29.1 (K), J1.5, J1.7, J1.11, J2.1, J2.MP (MountPin), J3.1, J3.MP (MountPin), J4.1, J5.1, J6.1, J6.MP (MountPin), J7.SH, J9.1, J9.MP (MountPin), J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.S1 (SHIELD), J11.6 (VSS), J11.MP (SHIELD), J12.1, J12.MP (MountPin), J13.1, J13.MP (MountPin), J14.1, J14.MP (MountPin), J15.1, J15.MP (MountPin), Q10.2 (S), Q11.2 (S), Q13.2 (S), Q20.2 (S), Q21.2 (S), Q23.2 (S), Q24.2 (S), Q25.2 (S), Q27.2 (S), R1.2, R2.2, R6.1, R7.1, R8.2, R9.1, R10.1, R12.2, R14.2, R16.2, R18.2, R20.2, R22.2, R25.2, R27.2, R29.2, R31.2, R33.2, R34.2, R36.2, R38.2, R40.2, R44.1, R47.2, R48.1, R49.1, R51.1, R52.1, R53.1, R55.1, R56.2, R57.2, R62.2, R63.1, R64.2, R65.1, R66.2, R67.1, R70.2, R74.2, R76.2, R78.2, R84.2, R87.2, R88.2, R89.2, R91.2, R95.2, R97.2, R100.1, R103.1, R105.2, R110.2, R117.2, R119.1, R122.2, R123.2, SW1.2 (B), SW5.2 (B), SW7.2 (B), TP3.1, U1.1 (GND), U1.2 (GND__1), U1.7 (GND__2), U1.8 (GND__3), U1.13 (GND__4), U1.14 (GND__5), U1.22 (GND__6), U1.23 (GND__7), U1.32 (GND__8), U1.33 (GND__9), U1.42 (GND__10), U1.43 (GND__11), U1.52 (GND__12), U1.53 (GND__13), U1.59 (GND__14), U1.60 (GND__15), U1.65 (GND__16), U1.66 (GND__17), U1.71 (GND__18), U1.74 (GND__19), U1.98 (GND__20), U1.107 (GND__21), U1.108 (GND__22), U1.113 (GND__23), U1.114 (GND__24), U1.119 (GND__25), U1.120 (GND__26), U1.125 (GND__27), U1.126 (GND__28), U1.131 (GND__29), U1.132 (GND__30), U1.137 (GND__31), U1.138 (GND__32), U1.144 (GND__33), U1.150 (GND__34), U1.155 (GND__35), U1.156 (GND__36), U1.161 (GND__37), U1.162 (GND__38), U1.167 (GND__39), U1.168 (GND__40), U1.173 (GND__41), U1.174 (GND__42), U1.179 (GND__43), U1.180 (GND__44), U1.185 (GND__45), U1.186 (GND__46), U1.191 (GND__47), U1.192 (GND__48), U1.197 (GND__49), U1.198 (GND__50), U2.5 (GND), U3.5 (GND), U4.5 (GND), U5.5 (GND), U6.6 (GND), U6.16 (GND), U7.A1 (GND), U7.A19 (GND), U7.A29 (GND), U7.A35 (GND), U7.A41 (GND), U7.A47 (GND), U7.A53 (GND), U7.A59 (GND), U7.B1 (GND), U7.B2 (GND), U7.B15 (GND), U7.B27 (GND), U7.B28 (GND), U7.B45 (GND), U7.B50 (GND), U7.B59 (GND), U7.B60 (GND), U8.5 (GND), U9.5 (GND), U10.5 (GND), U11.5 (GND), U12.5 (GND), U13.7 (GND), U13.9 (GND), U14.5 (GND), U15.10 (VSS), U15.19 (VSSA), U15.26 (VSS), U15.49 (VSS), U15.74 (VSS), U15.99 (VSS), U16.1 (GND), U17.4 (GND), U18.4 (GND), U19.4 (GND), U20.4 (GND), Y1.2, Y1.4
unnamed: C19.1, U15.48 (VCAP)
unnamed: C30.1, R68.2, R69.1
unnamed: C58.1, J10.A7 (D-), J10.B7 (D-), R115.2
unnamed: C59.1, J10.A6 (D+), J10.B6 (D+), R101.2
unnamed: C62.1, U15.73 (VCAP)
unnamed: D1.1 (K), J1.3, R1.1
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R5.1
unnamed: D7.1 (K), L1.1
unnamed: D9.2 (A), R71.1
unnamed: D10.2 (A), R72.1
unnamed: D11.2 (A), R73.1
unnamed: D12.2 (A), R80.1
unnamed: D13.2 (A), R81.1
unnamed: D14.2 (A), R82.1
unnamed: D15.2 (A), R83.1
unnamed: D16.1 (K), D18.1 (K), Q29.3 (G), R50.1
unnamed: C51.2, D17.1 (K), L2.1, U13.8 (SW)
unnamed: D19.2 (A), R3.1
unnamed: D20.2 (A), Q10.3 (D), R109.2
unnamed: D21.2 (A), R107.1
unnamed: D22.2 (A), R108.1
unnamed: D23.2 (A), Q24.3 (D), R113.2
unnamed: D24.2 (A), R111.1
unnamed: D25.2 (A), R112.1
unnamed: D26.2 (A), R114.1
unnamed: D28.2 (A), R42.1
unnamed: D29.2 (A), Q23.3 (D), R120.2
unnamed: J7.13, R94.2
unnamed: J7.15, R93.2
unnamed: C46.1, J7.5 (RCT), J7.11 (TCT)
unnamed: J10.A5 (CC1), R52.2
unnamed: J10.B5 (CC2), R51.2
unnamed: J13.2, Q26.3 (D)
unnamed: Q1.1 (B), R11.1
unnamed: Q1.3 (C), R12.1, U2.2 (~RE), U2.3 (DE)
unnamed: Q2.1 (B), R24.1
unnamed: Q2.3 (C), R25.1, U5.2 (~RE), U5.3 (DE)
unnamed: Q3.1 (B), R30.1
unnamed: Q3.3 (C), R31.1, U8.2 (~RE), U8.3 (DE)
unnamed: Q4.1 (B), R28.1
unnamed: Q4.3 (C), R34.1, U9.2 (~RE), U9.3 (DE)
unnamed: Q5.1 (B), R37.1
unnamed: Q5.3 (C), R38.1, U10.2 (~RE), U10.3 (DE)
unnamed: C21.2, Q6.1 (G), R46.2
unnamed: Q7.1 (B), Q7.3 (C), Q9.1 (B), R49.2
unnamed: Q8.1 (G), Q9.3 (C), R53.2
unnamed: Q11.3 (D), R61.2
unnamed: Q12.3 (G), R56.1, R58.2
unnamed: C23.2, Q14.3 (G), R59.2, R61.1
unnamed: Q15.1 (B), Q15.3 (C), Q17.1 (B), R63.2
unnamed: Q16.3 (G), Q17.3 (C), R65.2
unnamed: Q18.1 (B), R41.1
unnamed: Q18.3 (C), R74.1, U11.2 (~RE), U11.3 (DE)
unnamed: Q19.1 (B), R77.1
unnamed: Q19.3 (C), R78.1, U12.2 (~RE), U12.3 (DE)
unnamed: Q22.1 (B), R90.1
unnamed: Q22.3 (C), R95.1, U14.2 (~RE), U14.3 (DE)
unnamed: Q25.3 (D), Q26.1 (G), R102.1
unnamed: Q27.3 (D), Q28.1 (G), R104.1
unnamed: Q29.1 (D), Q29.2 (D), Q29.5 (D), Q29.6 (D), R45.1
unnamed: R43.1, R122.1
unnamed: R60.1, SW4.1 (A)
unnamed: R16.1, U3.2 (~RE), U3.3 (DE)
unnamed: R20.1, U4.2 (~RE), U4.3 (DE)
unnamed: R26.2, R27.1, U5.7 (B)
unnamed: C60.2, U6.3 (VCCIO), U6.13 (3V3OUT), U6.14 (~RESET)
unnamed: R115.1, U6.12 (USBDM)
unnamed: R101.1, U6.11 (USBDP)
unnamed: R86.1, U7.B25 (D7_DONE)
unnamed: R85.1, U7.B17 (E8_READY)
unnamed: R32.2, R33.1, U8.7 (B)
unnamed: R35.2, R36.1, U9.7 (B)
unnamed: R39.2, R40.1, U10.7 (B)
unnamed: R75.2, R76.1, U11.7 (B)
unnamed: R79.2, R87.1, U12.7 (B)
unnamed: C51.1, U13.1 (BOOT)
unnamed: R116.2, U13.6 (COMP)
unnamed: R119.2, U13.4 (RT/CLK)
unnamed: C70.1, U17.5 (Cdelay)
unnamed: R54.1, R57.1, U17.2 (IN)
unnamed: L4.1, U19.5 (SW)
unnamed: R118.1, R123.1, U20.2 (IN)
VBUS: C48.2, C61.1, J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS), Q6.2 (S), R44.2, R118.2, U6.15 (VCC)
VCC: C10.1, C16.1, C17.1, D4.1 (K), L1.2, R66.1, U13.2 (VIN)
VDD: D6.1 (K), D7.2 (A), Q14.1 (D), Q14.2 (D), Q14.5 (D), Q14.6 (D), R54.2, R64.1, R68.1

## KiCad design circuits/Wireless/3rdLayer/3rdLayer.kicad_pcb

Parts:
C4: 10uF; C_0805_2012Metric
C5, C6, C7, C8, C9, C10: 0.1uF; C_0402_1005Metric
C13, C14: 47pF; C_0603_1608Metric
J1: Conn_02x10_Odd_Even; PinHeader_2x10_P1.27mm_Vertical
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
R4, R5: 5.1k; R_0402_1005Metric
R6, R7: PullUP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R10, R11, R12, R13, R14: 10k; R_0402_1005Metric
R18, R19: 33; R_0603_1608Metric
SW1, SW2, SW3: SW_SPST; SW_SPST_Omron_B3FS-100xP
SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
U2: Display_Akzk_128x68OLED; Display_Aktk_128x68OLED_White
U3: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm

Connections:
+3.3V: C5.1, C6.1, C7.1, C8.1, R6.1, R7.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.5, SW4.6, SW4.7, SW4.8, U2.2 (VCC)
DIPSW0: R8.2, SW4.1
DIPSW1: R9.2, SW4.2
DIPSW2: R10.2, SW4.3
DIPSW3: R11.2, SW4.4
GNDD: C4.1, C7.2, C9.1, C10.2, C13.2, C14.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R4.1, R5.1, R8.1, R9.1, R10.1, R11.1, R12.2, R13.2, R14.2, U2.1 (GND), U3.6 (GND), U3.16 (GND)
I2C_SCL: R6.2, U2.3 (SCL)
I2C_SDA: R7.2, U2.4 (SDA)
unnamed: C13.1, J2.A7 (D-), J2.B7 (D-), R19.2
unnamed: C14.1, J2.A6 (D+), J2.B6 (D+), R18.2
unnamed: J2.A5 (CC1), R5.2
unnamed: J2.B5 (CC2), R4.2
unnamed: C9.2, U3.3 (VCCIO), U3.13 (3V3OUT), U3.14 (~RESET)
unnamed: R19.1, U3.12 (USBDM)
unnamed: R18.1, U3.11 (USBDP)
PRG_Twe: U3.19 (CBUS3)
RST_Twe: U3.10 (CBUS2)
TactSW0: C5.2, R12.1, SW1.1 (A)
TactSW1: C6.2, R13.1, SW2.1 (A)
TactSW2: C8.2, R14.1, SW3.1 (A)
TweWriteRX_TweTX: U3.4 (RXD)
TweWriteTX_TweRX: U3.20 (TXD)
VBUS: C4.2, C10.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U3.15 (VCC)

Notes on the sheet:
モニター
DIPスイッチ
モニター用タクトスイッチ
OLED
PinHeader
USB-C

Board: 2 copper layers, 30 parts (0 on the bottom side), 19 nets, no tracks yet.

## Commit log

2025-02-17 プロジェクト作成
2025-02-24 Driveほぼ完成
2025-02-28 無線&UI完成？
2025-03-03 ラズパイ基板とか
2025-03-27 PDFプロット
2025-04-04 add plotcode
2025-04-04 panelフットプリント配置
2025-04-04 シンボル・フットプリントMyLib->TomoshibiLib置き換え
2025-04-05 配線おけ
2025-06-09 raspi基板回路図
2025-06-24 発注_第一弾
    Drive, 1stLayer_Power, 2ndLayer_3rdLayer
    を発注
2025-07-19 発注第2弾
    RasPi発注
2025-07-24 バイブコーディング神
2025-09-04 PDF更新
2025-09-16 発注第3弾
    DCDC、MD追加
2025-10-27 Initial plan
